# Keil uVision project IPC15LTK.uvprojx, settings and files
target PWM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IPC15LTK +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE\TIMER;..\DSP_Lib\Include;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\BEE;..\HARDWARE\W25Q128;..\HARDWARE\HMC5883L;..\HARDWARE\IIC;..\HARDWARE\ICM20602;..\HARDWARE\SPI;..\HARDWARE\BMI088;..\HARDWARE\BMP280;..\HARDWARE\TIM;..\HARDWARE\CLOCK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../DSP_Lib/: arm_cortexM4lf_math.lib
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/LCD/: OLED.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEE/: bee.c
    ../HARDWARE/W25Q128/: w25q128.c
    ../HARDWARE/HMC5883L/: HMC5883L.c
    ../HARDWARE/IIC/: IIC1.c IIC2.c IIC3.c
    ../HARDWARE/ICM20602/: icm20602.c
    ../HARDWARE/SPI/: SPI1.c SPI2.c
    ../HARDWARE/BMI088/: BMI088.c
    ../HARDWARE/BMP280/: bmp280.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/CLOCK/: clock.c clock.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c lw_oopc.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_i2c.c
  group README
    ../: readme.txt
